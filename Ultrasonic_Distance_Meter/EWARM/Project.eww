<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Ultrasonic_Distance_Meter.ewp</path>
  </project>
  <batchBuild />
</workspace>
